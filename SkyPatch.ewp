# IAR project SkyPatch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151R6 ST STM32L151R6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: Source; Libraries\CMSIS\Device\ST\STM32L1xx\Include; Libraries\STM32L1xx_StdPeriph_Driver\inc; Libraries\BgLib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_STDPERIPH_DRIVER; DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: SkyPatch.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L100RB ST STM32L100RB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  AARM.ADefines: USE_STDPERIPH_DRIVER
  AARM.AUserIncludes: Source; Libraries\CMSIS\Device\ST\STM32L1xx\Include; Libraries\STM32L1xx_StdPeriph_Driver\inc; Libraries\SimpleBlueNRG_HCI\includes
  OBJCOPY.OOCOutputFile: c.srec
configuration 32L151C8T6 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
configuration Debug NoReboot (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; DISABLE_HARD_REBOOT; DISBALE_HEARTBEAT
configuration 32L151CBT6 NoReboot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  ICCARM.CCDefines: as above
configuration Debug Long (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; LONG_DELAY
configuration 32L151CBT6 Long (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; LONG_DELAY
  group Libraries/BgLib
    Libraries/BgLib/: bg_errorcodes.h bg_gattdb_def.h bg_types.h gecko_bglib.c gecko_bglib.h gecko_configuration.h host_gecko.h
  group Libraries/CMSIS
    Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
    Libraries/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Libraries/Peripheral
    Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    Libraries/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group Source
    Source/: app_data.c app_data.h bgm111.c bgm111.h i2c_bus.c i2c_bus.h imu_6axes.h lis3mdl.c lis3mdl.h lps25hb.c lps25hb.h lsm6ds3.c lsm6ds3.h magneto.h main.c misc_sense.c misc_sense.h opt3001.c opt3001.h pct2075.c pct2075.h pressure.h stm32l1xx_conf.h sys_ctrl.c sys_ctrl.h
